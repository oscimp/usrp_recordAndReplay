options:
  parameters:
    generate_options: no_gui
    id: record
    output_language: python
    title: record
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_frequency_Rx0
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: center_frequency_Rx1
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: gainRx0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gainRx1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: nber_channels
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx1.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: rx0.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bandwidth
    bw1: bandwidth
    center_freq0: center_frequency_Rx0
    center_freq1: center_frequency_Rx1
    clock_source0: external
    gain0: gainRx0
    gain1: gainRx1
    minoutbuf: '2097152'
    nchan: nber_channels
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
