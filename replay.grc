options:
  parameters:
    generate_options: no_gui
    id: replay
    output_language: python
    title: replay
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: center_frequency_Tx0
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: center_frequency_Tx1
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: gainTx0
  id: variable
  parameters:
    value: '10'
  states: {}
- name: gainTx1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: nber_channels
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: rx1.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: rx0.bin
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bandwidth
    bw1: bandwidth
    center_freq0: center_frequency_Tx0
    center_freq1: center_frequency_Tx1
    clock_source0: external
    gain0: gainTx0
    gain1: gainTx1
    nchan: nber_channels
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '1']
- [blocks_file_source_1, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
